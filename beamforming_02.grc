options:
  parameters:
    generate_options: qt_gui
    id: beamforming_02
    output_language: python
    title: Beamforming using modified ADALM Pluto
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '2_300_000_000'
  states: {}
- name: phase
  id: variable_qtgui_range
  parameters:
    label: Phase delay
    rangeType: int
    start: '-180'
    step: '2'
    stop: '180'
    value: '0'
    widget: eng_slider
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    start: '0'
    step: '1'
    stop: '71'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1_000_000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '100'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_phase_shift_0
  id: blocks_phase_shift
  parameters:
    is_radians: 'False'
    shift: phase
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: sps
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0, 1, 2, 3,0,0,1,1,3,3,2,2)
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: (-1-1j, -1+1j, +1-1j, +1+1j)
  states: {}
- name: iio_fmcomms2_source_0
  id: iio_fmcomms2_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: freq
    gain1: '''manual'''
    gain2: '''manual'''
    manual_gain1: rf_gain
    manual_gain2: rf_gain
    quadrature: 'True'
    rf_port_select: '''A_BALANCED'''
    rfdc: 'True'
    rx1_en: 'True'
    rx2_en: 'True'
    samplerate: samp_rate
    type: fc32
    uri: 'usb:'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '30.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'True'
    filter_source: '''Auto'''
    frequency: freq
    samplerate: samp_rate
    type: fc32
    uri: 'usb:'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: '[4,1]'
    name: '"RX[0+1+ph_del] Constellation"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: '[4,0]'
    name: '"TX constellation"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '512'
    grid: 'True'
    gui_hint: '[0,0]'
    name: '"RX0"'
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '512'
    grid: 'True'
    gui_hint: '[0,1]'
    name: '"RX1 + Phase shift"'
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '512'
    grid: 'True'
    gui_hint: '[2,0]'
    name: '"RX0+RX1 (Added)"'
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_freq_sink_x_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '512'
    grid: 'True'
    gui_hint: '[2,1]'
    name: '"RX0-RX1 (Substract)"'
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: '[4,0]'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}

connections:
- [blocks_add_xx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0_1, '0']
- [blocks_phase_shift_0, '0', blocks_add_xx_0, '1']
- [blocks_phase_shift_0, '0', blocks_sub_xx_0, '1']
- [blocks_phase_shift_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_repeat_0, '0', iio_pluto_sink_0, '0']
- [blocks_repeat_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_repeat_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_sub_xx_0, '0', qtgui_freq_sink_x_0_1_0, '0']
- [blocks_vector_source_x_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_repeat_0, '0']
- [iio_fmcomms2_source_0, '0', blocks_add_xx_0, '0']
- [iio_fmcomms2_source_0, '0', blocks_sub_xx_0, '0']
- [iio_fmcomms2_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_fmcomms2_source_0, '1', blocks_phase_shift_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
